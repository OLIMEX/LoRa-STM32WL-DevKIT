# Repository OLIMEX/LoRa-STM32WL-DevKIT

File README.md:

# LoRa-STM32WL-DevKIT
STM32WL SOC LoRa / LoRaWAN development board with JTAG debugger and sensors for light (photoresistor), temperature and humidity (AHT20, BME280 in older revisions), and 3-axis digital magnetometer (IIS2MDCTR)

Product page: https://www.olimex.com/Products/IoT/LoRa/LoRa-STM32WL-DevKit/

## License
* Hardware design is released under CERN OHL v1.2 license
* Software is released under GPL3 License
* Documentation is released under CC BY-SA 3.0

## KiCad design HARDWARE/LoRa-STM32WL-DevKIT/LoRa-STM32WL-DevKit-RevB/BackupFiles/STM32WL-DevKit_RevB.kicad_pcb

Schematic: STM32WL-DevKit_RevB.sch, LoRa - STM32WL Dev Kit

Parts:
BAT1: Battery; BATTERY-1xAA
C1, C4, C7, C9: 4.7uF_6.3V; C_0603_5MIL_DWS
C5: 2.2uF_6.3V; C_0402_5MIL_DWS
C6, C8, C10: 220nF; C_0402_5MIL_DWS
CON1: CON10; HN1x10
D1: 1N5819; SOD-123_KA
FET1: WPM2015; SOT23
JP2: JP1E; HN1x2_Jumper
MOD1: BB-STM32WL; BB-STM32WLE
R1, R5, R6: 220R; R_0402_5MIL_DWS
R8: R_PHOTO-Device; R_PHOTO
R9, R18: 10K; R_0402_SMALL
R10, R11: 10k; R_0402_5MIL_DWS
SJ1: SJ_Closed; SJ_1_SMALLER_TIED
SW1, SW2: T1107A(6x3,8x2,5MM)
U1: ME6210-SOT89; SOT89
U3: IIS2MDC; LGA-12_2X2_0.5
U4: BME280
UEXT1: BH10S; GBH-254-SMT-10

Connections:
+3.3V: C4.1, D1.2, FET1.1, R18.2, U1.3
/CMSIS-DAP/5V_USB: C1.2, U1.2; also elsewhere on the board
/CMSIS-DAP/USART_RX: R5.2; also elsewhere on the board
/CMSIS-DAP/USART_TX: R6.2; also elsewhere on the board
/CMSIS-DAP/nRESET: R1.2; also elsewhere on the board
/SWCLK1: MOD1.1; also elsewhere on the board
/SWCLK2: CON1.8; also elsewhere on the board
/SWDIO1: MOD1.2; also elsewhere on the board
/SWDIO2: CON1.9; also elsewhere on the board
/nBOOT0: MOD1.10; also elsewhere on the board
GND: BAT1.2, C1.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.2, CON1.2, CON1.10, MOD1.8, MOD1.18, R9.1, R18.1, SW1.2, SW2.2, U1.1, U3.6, U3.8, U4.1, U4.7, UEXT1.2; also elsewhere on the board
NRST: MOD1.6, R1.1, SW1.1
unnamed: BAT1.1, JP2.1
unnamed: C6.1, U3.5
unnamed: FET1.3, JP2.2
PA0: C10.1, CON1.6, MOD1.14, SW2.1
PA1: CON1.5, MOD1.15
PA2: MOD1.19, UEXT1.3
PA3: MOD1.20, UEXT1.4
PA4: MOD1.21, UEXT1.10
PA5: MOD1.22, UEXT1.9
PA6: CON1.3, MOD1.17
PA7: MOD1.23, UEXT1.8
PA8: MOD1.12, U3.7
PA9: MOD1.4, R11.2, U3.1, U4.4, UEXT1.5
PA10: MOD1.3, R10.2, U3.4, U4.3, UEXT1.6
PA11: MOD1.24, UEXT1.7
PB2: MOD1.5
PB4: CON1.7, MOD1.13, R8.2, R9.2, SJ1.1, SJ1.2
PB6: MOD1.11, R5.1
PB7: MOD1.9, R6.1
PB12: CON1.4, MOD1.16, R8.1
VDD: C5.1, C7.1, C8.1, C9.2, CON1.1, D1.1, FET1.2, MOD1.7, R10.1, R11.1, U3.3, U3.9, U3.10, U4.2, U4.5, U4.6, U4.8, UEXT1.1; also elsewhere on the board

Notes on the sheet:
VIN
PGM/DEBUG UART 115200
TARGET
CMSIS-DAP USB ACM device

Parts:
C2, C3, C12: 100n; C_0402_5MIL_DWS
C11: 2.2 uF; C_0402_5MIL_DWS
LED1: RLED; LED_0603_KA
LED2: GLED; LED_0603_KA
LED3: BLED; LED_0603_KA
R2, R4: 1.5K; R_0402_5MIL_DWS
R3, R14, R16: 2.2K; R_0402_5MIL_DWS
R7, R12: 22R; R_0402_5MIL_DWS
R13, R15, R17: 10K; R_0402_5MIL_DWS
SB1: SJ; WU02S
U2: STM32L052K8Ux; QFN-32_EP_5.3x5.3_Pitch0.5mm
USB1: USB-DEBUG; USB-MICRO_MISB-SWMM-5B_LF

Connections:
/CMSIS-DAP/5V_USB: R2.2, USB1.1 (VBUS); also elsewhere on the board
/CMSIS-DAP/USART_RX: U2.9 (PA3); also elsewhere on the board
/CMSIS-DAP/USART_TX: U2.8 (PA2); also elsewhere on the board
/CMSIS-DAP/USBD_DN: R7.1, USB1.2 (D-)
/CMSIS-DAP/USBD_DP: R4.1, R12.1, USB1.3 (D+)
/CMSIS-DAP/USBD_N: R7.2, U2.21 (PA11)
/CMSIS-DAP/USBD_P: R12.2, U2.22 (PA12)
/CMSIS-DAP/VDEB: R2.1, R3.2, U2.13 (PA7)
/CMSIS-DAP/nRESET: U2.32 (PB8); also elsewhere on the board
/SWCLK1: U2.11 (PA5); also elsewhere on the board
/SWCLK2: U2.24 (PA14); also elsewhere on the board
/SWDIO1: U2.10 (PA4); also elsewhere on the board
/SWDIO2: U2.23 (PA13); also elsewhere on the board
/nBOOT0: U2.30 (PB7); also elsewhere on the board
GND: C2.2, C3.2, C11.2, C12.2, LED1.1 (K), LED2.1 (K), LED3.1 (K), R3.1, R17.1, SB1.2, U2.33 (VSS), USB1.0, USB1.5 (GND); also elsewhere on the board
unnamed: C12.1, R13.1, U2.4 (NRST)
unnamed: LED1.2 (A), R16.2
unnamed: LED2.2 (A), R15.2
unnamed: LED3.2 (A), R14.2
unnamed: R4.2, U2.25 (PA15)
unnamed: R14.1, U2.26 (PB3)
unnamed: R15.1, U2.27 (PB4)
unnamed: R16.1, U2.28 (PB5)
unnamed: R17.2, U2.31 (BOOT0)
unnamed: SB1.1, U2.12 (PA6)
VDD: C2.1, C3.1, C11.1, R13.2, U2.1 (VDD), U2.5 (VDDA), U2.17 (VDD); also elsewhere on the board

Notes on the sheet:
Bootloader

Board: 4 copper layers, 58.4 x 55.9 mm, 55 parts (1 on the bottom side), 47 nets.

Other parts of the board:
MountingHole*: Rubber_feet
MountingHole*#2, MountingHole*#3, MountingHole*#4: Rubber_feet
Ref*: Val**; Fiducial1x3_transp
Ref*#2: Val**; Fiducial1x3_transp

## Code that names these connections

File SOFTWARE/Old-revision-demo/BB-STM32WLE-WAN/BB-STM32WLE-WAN.ioc (part):

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Mcu.Name=STM32WLE5CCUx
Mcu.Package=UFQFPN48
Mcu.UserName=STM32WLE5CCUx
PA0.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PA0.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA0.GPIO_PuPd=GPIO_PULLUP
PA0.Signal=GPXTI0
PA1.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PA1.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA1.GPIO_PuPd=GPIO_PULLUP
PA1.Signal=GPXTI1
PA10.GPIOParameters=GPIO_Pu
PA10.GPIO_Pu=GPIO_PULLUP
PA10.Mode=I2C
PA10.Signal=I2C1_SDA
PA11.Mode=Full_Duplex_Master
PA11.Signal=SPI1_MISO
PA13.Signal=DEBUG_JTMS-SWDIO
PA15.GPIOParameters=GPIO_Label
PA15.GPIO_Label=LED
PA15.Signal=GPIO_Output
PA2.Mode=Asynchronous
PA2.Signal=LPUART1_TX
PA3.Mode=Asynchronous
PA3.Signal=LPUART1_RX
PA4.Mode=NSS_Signal_Hard_Output
PA4.Signal=SPI1_NSS
PA5.Mode=Full_Duplex_Master
PA5.Signal=SPI1_SCK
PA6.GPIOParameters=GPIO_PuPd,GPIO_ModeDefaultEXTI
PA6.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PA6.GPIO_PuPd=GPIO_PULLUP
PA6.Signal=GPXTI6
PA7.Mode=Full_Duplex_Master
PA7.Signal=SPI1_MOSI
PA8.Signal=GPIO_Analog
PA9.GPIOParameters=GPIO_Pu
PA9.GPIO_Pu=GPIO_PULLUP
PA9.Mode=I2C
PA9.Signal=I2C1_SCL
PB0-VDD_TCXO.Signal=GPIO_Analog
PB12.GPIOParameters=PinState,GPIO_Label
PB12.GPIO_Label=AMB_PWR
PB12.PinState=GPIO_PIN_SET
PB12.Signal=GPIO_Output
PB2.GPIOParameters=GPIO_Label
PB2.GPIO_Label=DUMMY
PB2.Signal=GPIO_Output
PB3.GPIOParameters=GPIO_Label
PB3.GPIO_Label=LED2
PB3.Signal=GPIO_Output
PB4.GPIOParameters=GPIO_Label
PB4.GPIO_Label=AMB
PB4.Signal=SharedAnalog_PB4
PB5.GPIOParameters=GPIO_Label
PB5.GPIO_Label=LED3
PB5.Signal=GPIO_Output
PB6.Mode=Asynchronous
PB6.Signal=USART1_TX
PB7.Mode=Asynchronous
PB7.Signal=USART1_RX
PB8.GPIOParameters=GPIO_Label
PB8.GPIO_Label=FE_CTRL2
PB8.Signal=GPIO_Output
PC13.GPIOParameters=PinState,GPIO_Label
PC13.GPIO_Label=FE_CTRL1
PC13.PinState=GPIO_PIN_SET
PC13.Signal=GPIO_Output
PC14-OSC32_IN.Mode=LSE-External-Oscillator
PC14-OSC32_IN.Signal=RCC_OSC32_IN
PC15-OSC32_OUT.Mode=LSE-External-Oscillator
PC15-OSC32_OUT.Signal=RCC_OSC32_OUT
RCC.HSE_VALUE=32000000
RCC.SYSCLKFreq_VALUE=16000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_HSI
board=custom

## Commit log (part)

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2021-11-23 initial upload docs
2022-02-02 Fix
    Added missing files
2022-08-13 remove duplicate, conflicting declaration of hsubghz
2022-08-13 add missing include to sysmem.c
2022-08-13 add README.md to mention wireless region
2022-08-13 add USE_BSP_DRIVER #define
2022-08-25 software: fix code duplication
    fix build error:
    arm-none-eabi-gcc -o "BB-STM32WLE-WAN.elf" @"objects.list" -mcpu=cortex-m4 -T"/LoRa-STM32WL-DevKIT/SOFTWARE/BB-STM32WLE-WAN/STM32WLE5CCUX_FLASH.ld" --specs=nosys.specs -Wl,-Map="BB-STM32WLE-WAN.map" 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
    arm-none-eabi/bin/ld: ./Core/Src/subghz.o:/LoRa-STM32WL-DevKIT/SOFTWARE/BB-STM32WLE-WAN/Debug/../Core/Src/subghz.c:27: multiple definition of `hsubghz'; ./Core/Src/main.o:/LoRa-STM32WL-DevKIT/SOFTWAR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
    arm-none-eabi/bin/ld: warning: BB-STM32WLE-WAN.elf has
2022-08-25 software: verify and exit after flashing
2023-03-29 Update
    Hardware revision D1
2023-12-20 Update
    Demo updated for latest hardware revision with power control pin and new AHT20 sensor
2023-12-21 Revert "Delete .gitmodules"
    This reverts commit 203773a0498f557001ece2dd28371e41e13d5fb4.
2023-12-21 Revert
2025-09-26 Update
    PlatformIO json

Notices in the files:
HARDWARE/LoRa-STM32WL-DevKIT/LoRa-STM32WL-DevKit-RevB/BackupFiles/STM32WL-DevKit_RevB.kicad_pcb:
(c)2021
